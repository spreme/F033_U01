# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Porject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Libary\CMSIS\Include;..\Libary\Device\CMS32F033\Include;..\Libary\StdDriver\inc;..\code;..\code\mcu_sdk
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Libary/Device/CMS32F033/Source/ARM/: startup_cms32f033x.s
    ../Libary/Device/CMS32F033/Source/: system_cms32f033x.c
  group User
    ../code/: main.c isr.c motor.c led.c rtc.c tuya_wifi.c feed_process.c
  group user_config
    ../code/: user_gpio.c user_time.c user_uart.c user_flash.c
  group protocol
    ../code/: define.h user_gpio.h
  group TY_SDK
    ../code/mcu_sdk/: mcu_api.c protocol.c system.c
  group LIB
    ../Libary/StdDriver/src/: acmp.c adc1.c ccp.c crc.c epwm.c fmc.c gpio.c hwdiv.c i2c.c opa.c pga.c retarget.c ssp.c system.c timer.c uart.c wdt.c wwdt.c
